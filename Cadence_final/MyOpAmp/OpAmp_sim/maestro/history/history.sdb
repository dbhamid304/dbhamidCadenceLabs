<?xml version="1.0"?>
<setupdb version="7">history
	<active>Active Setup</active>
	<history>History
		<historyentry assemblerOrExplorer="assembler" roOrView="view" runningOrFinished="finished">Interactive.0
			<timestamp>Jul 25 20:17:56 2024</timestamp>
			<uuid>{22381a7b-0fd8-4e83-ba42-61007e1ecb9f}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultspsfisuserpath>1</resultspsfisuserpath>
			<resultsname>/servers/esd_noida/steja/Basic_Analog_Flow/final/CAICDF/solutions/module4/MyOpAmp/OpAmp_sim/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/servers/esd_noida/steja/Basic_Analog_Flow/final/CAICDF/solutions/module4/MyOpAmp/OpAmp_sim/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/servers/esd_noida/steja/Basic_Analog_Flow/final/CAICDF/solutions/module4/simulation/MyOpAmp/OpAmp_sim/maestro/results/maestro/$AXL_HISTORY_NAME</psfdir>
			<simdir>./simulation/MyOpAmp/OpAmp_sim/maestro/results/maestro/$AXL_HISTORY_NAME</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.0
			<timestamp>Jul 25 21:47:07 2024</timestamp>
			<uuid>{aac090ef-b1d5-456c-8ac6-297eb7714b6e}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultspsfisuserpath>1</resultspsfisuserpath>
			<resultsname>/servers/esd_noida/steja/Basic_Analog_Flow/final/CAICDF/solutions/module4/MyOpAmp/OpAmp_sim/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/servers/esd_noida/steja/Basic_Analog_Flow/final/CAICDF/solutions/module4/MyOpAmp/OpAmp_sim/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/servers/esd_noida/steja/Basic_Analog_Flow/final/CAICDF/solutions/module4/./simulation/MyOpAmp/OpAmp_sim/maestro/results/maestro/$AXL_HISTORY_NAME</psfdir>
			<simdir>./simulation/MyOpAmp/OpAmp_sim/maestro/results/maestro/$AXL_HISTORY_NAME</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="assembler" roOrView="view" runningOrFinished="finished">Interactive.1
			<timestamp>Jul 25 21:52:54 2024</timestamp>
			<uuid>{f41156ae-3d3f-4533-b91d-597f5d0f446e}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultspsfisuserpath>1</resultspsfisuserpath>
			<resultsname>/servers/esd_noida/steja/Basic_Analog_Flow/final/CAICDF/solutions/module4/MyOpAmp/OpAmp_sim/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/servers/esd_noida/steja/Basic_Analog_Flow/final/CAICDF/solutions/module4/MyOpAmp/OpAmp_sim/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/servers/esd_noida/steja/Basic_Analog_Flow/final/CAICDF/solutions/module4/simulation/MyOpAmp/OpAmp_sim/maestro/results/maestro/$AXL_HISTORY_NAME</psfdir>
			<simdir>./simulation/MyOpAmp/OpAmp_sim/maestro/results/maestro/$AXL_HISTORY_NAME</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="assembler" roOrView="view" runningOrFinished="finished">Interactive.2
			<timestamp>Jul 25 21:54:44 2024</timestamp>
			<uuid>{71011af9-4fe4-4dc0-b13d-0b761095db7b}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultspsfisuserpath>1</resultspsfisuserpath>
			<resultsname>/servers/esd_noida/steja/Basic_Analog_Flow/final/CAICDF/solutions/module4/MyOpAmp/OpAmp_sim/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/servers/esd_noida/steja/Basic_Analog_Flow/final/CAICDF/solutions/module4/MyOpAmp/OpAmp_sim/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/servers/esd_noida/steja/Basic_Analog_Flow/final/CAICDF/solutions/module4/simulation/MyOpAmp/OpAmp_sim/maestro/results/maestro/$AXL_HISTORY_NAME</psfdir>
			<simdir>./simulation/MyOpAmp/OpAmp_sim/maestro/results/maestro/$AXL_HISTORY_NAME</simdir>
		</historyentry>
	</history>
</setupdb>
